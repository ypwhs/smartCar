# Keil uVision project templete.uvproj, settings and files
target mkl46z_flash (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x6000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./mkl46z4/flash/templete.bin
  c flags: Optim=1
  c define: MKL46Z4
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\KL\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  group startup_mkl46z4
    ../../../../Libraries/startup/DeviceSupport/: system_MKL46Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL46Z4.s
  group startup_mkl25z4
    ../../../../Libraries/startup/DeviceSupport/: system_MKL25Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL25Z4.s
  group startup_mkl26z4
    ../../../../Libraries/startup/DeviceSupport/: system_MKL26Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL26Z4.s
  group startup_mkl43z4
    ../../../../Libraries/startup/DeviceSupport/: system_MKL43Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL43Z4.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c gpio.c systick.c uart.c adc.c dma.c i2c.c lptmr.c pit.c tpm.c spi.c
  group dsp_lib
    ../../../../Libraries/drivers/KL/src/dsp/lib/: arm_cortexM0l_math.lib
target mkl25z4_flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./mkl25z4/flash/templete.bin
  c flags: Optim=1
  c define: MKL25Z4
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
target mkl26z4_flash (ARM-ADS)
  device: MKL26Z128xxx4 Freescale
  cpu: as above
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./mkl26z4/flash/templete.bin
  c flags: Optim=1
  c define: MKL26Z4
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
target mkl43z4_flash (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./mkl26z4/flash/templete.bin
  c flags: Optim=1
  c define: MKL43Z4
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
