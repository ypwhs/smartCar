# IAR project Backup of templete.ewp, settings and files
configuration mkl26z4 (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z64xxx4 Freescale MKL26Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MKL26Z4; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\drivers\KL\inc; ..\..\..\..\Libraries\startup\CoreSupport; ..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\..\Libraries\startup\DeviceSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: templete.bin
  ILINK.IlinkOutputFile: templete.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c gpio.c i2c.c systick.c uart.c
  group startup_mkl26
    ../../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MKL26Z4.s
    ../../../../Libraries/startup/DeviceSupport/: system_MKL26Z4.c
  group user
    ../src/: main.c
