# Keil uVision project templete.uvproj, settings and files
target MK60F15 (ARM-ADS)
  device: MK60FN1M0xxx15 Freescale Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(150000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK60F15
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;D:\Software\Keil_V4\ARM\Flash
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup_mk60d10
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group startup_mk64f12
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK64F12.s
  group statup_mk60f15
    ../../../../Libraries/startup/DeviceSupport/: system_MK60F15.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60F15.s
  group startup_mk10d5
    ../../../../Libraries/startup/DeviceSupport/: system_MK10D5.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK10D5.s
  group startup_mk70f15
    ../../../../Libraries/startup/DeviceSupport/: system_MK70F15.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK70F15.s
  group startup_mk22f12
    ../../../../Libraries/startup/DeviceSupport/: system_MK22F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK22F12.s
  group user
    ../src/: main.c
  group drivers_k
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c systick.c common.c pit.c adc.c can.c cmp.c cpuidy.c crc.c dac.c dma.c enet.c flexbus.c ftm.c i2c.c lptmr.c pdb.c rtc.c sd.c spi.c tsi.c vref.c nfc.c
  group ssd_lib
    ../../../../Libraries/drivers/K/src/flash/lib/: MK_P1M0.lib MK_P32_50MHZ.lib MK_P512.lib
  group dsp_lib
    ../../../../Libraries/drivers/K/src/dsp/lib/: arm_cortexM4l_math.lib arm_cortexM4lf_math.lib
  group devices
    ../../../../Libraries/devices/src/: MT47H64M16HR.c
target MK60D10 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK60D10
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
target MK64F12 (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK64F12
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
target MK10D5 (ARM-ADS)
  device: MK10DN32xxx5 Freescale Semiconductor
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) IRAM2(0x1FFFF000,0x1000) CPUTYPE("Cortex-M4") CLOCK(50000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK10D5
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
target MK70F15 (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK70F15
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
target MK22F12 (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale
  cpu: as above
  output: templete +hex
  c flags: Optim=1
  c define: MK22F12
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
