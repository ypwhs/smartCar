# Keil uVision project templete.uvproj, settings and files
target mkl26z4_flash (ARM-ADS)
  device: MKL25Z64xxx4 Freescale Semiconductor
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF800,0x2000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./mkl26z4/flash/templete.bin
  c flags: Optim=4 uC99=1
  c define: MKL26Z4,USE_MPU9250,USE_AK8963
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\KL\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;..\..\..\..\Libraries\utilities\imu
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  group startup_mkl26z4
    ../../../../Libraries/startup/DeviceSupport/: system_MKL26Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL26Z4.s
  group user
    ../src/: main.c scope.c protocol.c CHZT02.c CH9250.c
    ../../../../Libraries/devices/src/: mpu9250.c
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c gpio.c systick.c uart.c dma.c i2c.c pit.c
  group dsp_lib
    ../../../../Libraries/drivers/KL/src/dsp/lib/: arm_cortexM0l_math.lib
  group utilities
    ../../../../Libraries/utilities/imu/: imu.c
