# Keil uVision project templete.uvproj, settings and files
target MK60F15 (ARM-ADS)
  device: MK60FN1M0xxx15 Freescale Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(150000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK60F15
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;D:\Software\Keil_V4\ARM\Flash
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group statup_mk60f15
    ../../../../Libraries/startup/DeviceSupport/: system_MK60F15.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60F15.s
  group user
    ../src/: main.c
  group drivers_k
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c systick.c common.c pit.c adc.c can.c cmp.c cpuidy.c crc.c dac.c dma.c enet.c flexbus.c ftm.c i2c.c lptmr.c pdb.c rtc.c sd.c spi.c tsi.c vref.c
  group ssd_lib
    ../../../../Libraries/drivers/K/src/flash/lib/: MK_P1M0.lib MK_P32_50MHZ.lib MK_P512.lib
  group dsp_lib
    ../../../../Libraries/drivers/K/src/dsp/lib/: arm_cortexM4l_math.lib arm_cortexM4lf_math.lib
  group devices
    ../../../../Libraries/devices/src/: cy7c027.c
