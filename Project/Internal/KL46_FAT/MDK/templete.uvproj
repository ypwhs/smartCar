# Keil uVision project templete.uvproj, settings and files
target mkl46z4_flash (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x6000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./OBJ/flash/templete.bin
  c flags: Optim=1
  c define: MKL46Z4 RADIUM LIB_DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\KL\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;..\..\..\..\Libraries\utilities\shell;..\..\..\..\Libraries\utilities\board;..\..\..\..\Libraries\utilities\chgui
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  link misc: --keep __fsym_*
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MKL46Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL46Z4.s
  group user
    ../src/: main.c shell_config.h cmd_tpm.c
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c gpio.c systick.c uart.c adc.c pit.c dma.c tpm.c lptmr.c i2c.c spi.c
  group devices
    ../../../../Libraries/devices/src/: spi_bus_ops.c ili9163.c spi_bus_ops_kl.c
  group utilities/chgui
    ../../../../Libraries/utilities/chgui/: chgui.c
  group utilities/hw_test
    ../../../../Libraries/utilities/board/: cmd_test_gpio.c cmd_test_pit.c cmd_test_i2c.c cmd_test_uart.c cmd_test_adc.c cmd_test_key.c cmd_test_lptmr.c cmd_test_spi.c cmd_test_ili9163.c cmd_test_reset.c cmd_test_dma.c
  group utilities/shell
    ../../../../Libraries/utilities/shell/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
