# Keil uVision project templete.uvproj, settings and files
target raven (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete
  c flags: Optim=1
  c define: MK60D10 RAVEN
  c misc: --c99 --gnu
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\shell;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;..\..\..\..\Libraries\d4d\common_files;..\..\..\..\Libraries\d4d\graphic_objects;..\..\..\..\Libraries\d4d;..\..\..\..\Libraries\utilities\board;..\..\..\..\Libraries\utilities\mempool;..\..\..\..\Libraries\utilities\fatfs;..\..\..\..\Libraries\drivers\K\src\usb\inc;..\..\..\..\Libraries\drivers\K\src\usb\src\descriptor\hid_mouse;..\..\..\..\Libraries\utilities\i2c_sim
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --keep __fsym_*
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c system_MK64F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s startup_MK64F12.s
  group user
    ../src/: main.c cmd_cpuinfo.c cmd_spi.c cmd_ov7620.c cmd_tsi.c shell_config.h
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c lptmr.c dma.c flexbus.c systick.c rtc.c enet.c tsi.c common.c sd.c pdb.c crc.c
  group utilities\shell
    ../../../../Libraries/utilities/shell/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
  group devices
    ../../../../Libraries/devices/src/: ili9320.c ov7620.c sram.c ads7843.c w25qxx.c adxl345.c at24cxx.c spi_bus_ops.c i2c_bus_ops.c ksz8041.c
  group utilites\board
    ../../../../Libraries/utilities/board/: cmd_test_adc.c cmd_test_gpio.c cmd_test_i2c.c cmd_test_key.c cmd_test_lptmr.c cmd_test_pit.c cmd_test_uart.c cmd_test_dma.c cmd_test_wdog.c cmd_test_clkout.c cmd_test_pdb.c cmd_test_sd.c cmd_test_ili9320.c cmd_test_sram.c cmd_test_rtc.c cmd_test_enet.c cmd_test_cpuidy.c cmd_test_usb.c cmd_test_crc.c
  group utilities\fafats
    ../../../../Libraries/utilities/fatfs/: diskio.c ff.c
  group drivers\usb\src\class
    ../../../../Libraries/drivers/K/src/usb/src/class/hid/: usb_hid.c
    ../../../../Libraries/drivers/K/src/usb/src/descriptor/hid_mouse/: usb_descriptor.c
  group drivers\usb\src\common
    ../../../../Libraries/drivers/K/src/usb/src/common/: usb.c usb_class.c usb_framework.c
  group drivers\usb\src\driver
    ../../../../Libraries/drivers/K/src/usb/src/driver/: usb_dci_kinetis.c usb_driver.c usbevent.c
  group utilities\i2c_sim
    ../../../../Libraries/utilities/i2c_sim/: i2c_sim.c
target frdmk64f12 (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templete
  c flags: Optim=1
  c define: MK64F12 RAVEN LIB_DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\shell;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;..\..\..\..\Libraries\d4d\common_files;..\..\..\..\Libraries\d4d\graphic_objects;..\..\..\..\Libraries\d4d;..\..\..\..\Libraries\utilities\board;..\..\..\..\Libraries\utilities\mempool;..\..\..\..\Libraries\utilities\fatfs;..\..\..\..\Libraries\utilities\i2c_sim
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --keep __fsym_*
target net_5000 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: as above
  output: templete
  c flags: Optim=1
  c define: MK60D10 NET_5000 LIB_DEBUG
  c misc: --c99 --gnu
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\shell;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;..\..\..\..\Libraries\d4d\common_files;..\..\..\..\Libraries\d4d\graphic_objects;..\..\..\..\Libraries\d4d;..\..\..\..\Libraries\utilities\board;..\..\..\..\Libraries\utilities\mempool;..\..\..\..\Libraries\utilities\fatfs;..\..\..\..\Libraries\drivers\K\src\usb\inc;..\..\..\..\Libraries\drivers\K\src\usb\src\descriptor\hid_mouse
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --keep __fsym_*
