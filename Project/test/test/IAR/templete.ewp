# IAR project templete.ewp, settings and files
configuration mk60d10 (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MK60D10; DEBUG
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\drivers\K\inc; ..\..\..\..\Libraries\drivers\K\src; ..\..\..\..\Libraries\devices\inc; ..\..\..\..\Libraries\startup\CoreSupport; ..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\..\Libraries\startup\DeviceSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: templete.bin
  ILINK.IlinkOutputFile: templete.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration mk64f12 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  ICCARM.CCDefines: MK64F12; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\drivers\K\inc; ..\..\..\..\Libraries\startup\CoreSupport; ..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\..\Libraries\startup\DeviceSupport
  group drivers
    ../../../../Libraries/drivers/K/src/: adc.c can.c cmp.c common.c cpuidy.c crc.c dac.c dma.c enet.c flexbus.c ftm.c gpio.c i2c.c lptmr.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
    ../../../../Libraries/drivers/K/inc/: i2c.h
    ../../../../Libraries/devices/src/: ov7725.c
    ../../../../Libraries/devices/inc/: ov7725.h
  group startup_mk60d10
    ../../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
  group statup_mk64f12
    ../../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK64F12.s
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
  group user
    ../src/: camera_dma.c camera_dma.h main.c oled_spi.c oled_spi.h
