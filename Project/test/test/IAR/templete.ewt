<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>mk60d10</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>mk64f12</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>drivers</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\cmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\cpuidy.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\enet.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\flexbus.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\ftm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\devices\src\ov7725.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\devices\inc\ov7725.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\pdb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\pit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\sd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\tsi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\vref.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\drivers\K\src\wdog.c</name>
    </file>
  </group>
  <group>
    <name>startup_mk60d10</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM\startup_MK60D10.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\startup\DeviceSupport\system_MK60D10.c</name>
    </file>
  </group>
  <group>
    <name>statup_mk64f12</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM\startup_MK64F12.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\startup\DeviceSupport\system_MK64F12.c</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\..\src\main.c</name>
      <configuration>
        <name>mk60d10</name>
      </configuration>
    </file>
  </group>
</project>


